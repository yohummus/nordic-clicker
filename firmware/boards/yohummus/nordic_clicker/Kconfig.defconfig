## firmware/boards/yohummus/nordic_clicker/Kconfig.defconfig
```kconfig
if BOARD_NORDIC_CLICKER

config BT_CTLR
	default BT

endif # BOARD_NORDIC_CLICKER
```
